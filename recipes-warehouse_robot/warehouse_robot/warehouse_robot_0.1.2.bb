include warehouse_robot.inc

LICENSE = "LGPL-3.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e6a600fd5e1d9cbde2d983680233ad02"

SRC_URI[md5sum] = "ce4e680c052fc8b86834ac5e99110caa"
SRC_URI[sha256sum] = "3fcbf34f0b9b4bc76afc57e13868cc1f5787ae961c334118c4c95065cd876b06"

