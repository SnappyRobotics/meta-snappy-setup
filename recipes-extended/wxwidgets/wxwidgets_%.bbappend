FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://webkit_gtk_fix.patch \
"
