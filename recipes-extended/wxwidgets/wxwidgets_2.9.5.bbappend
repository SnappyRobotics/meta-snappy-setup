FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-Solved-link-problem-with-webkit-gtk.patch \
"
