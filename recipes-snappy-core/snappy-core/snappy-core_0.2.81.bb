include snappy-core.inc

LICENSE = "LGPL-3.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e6a600fd5e1d9cbde2d983680233ad02"

SRC_URI[md5sum] = "cd29d96c0bac6761cca783887d11a170"
SRC_URI[sha256sum] = "91e57603f8af74e14eb586f16108af4c50a3516c8fdac62a1c0aa90b62de609c"

