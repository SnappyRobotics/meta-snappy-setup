include snappy-core.inc

LICENSE = "LGPL-3.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e6a600fd5e1d9cbde2d983680233ad02"

SRC_URI[md5sum] = "7aadfe42bfd4e568b2565b997a552031"
SRC_URI[sha256sum] = "c3994a316cfeaa37efec5a88b1d7dc21efeb59f8e1456df3eaffe72f3a3d8679"

