include snappy-core.inc

LICENSE = "LGPL-3.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e6a600fd5e1d9cbde2d983680233ad02"

SRC_URI[md5sum] = "4489ecc5fa1429e578bd98afe43f5f4c"
SRC_URI[sha256sum] = "cd6ec104c351de1513d474077cd6749dccf533d589620e3bb21e1c92733cc329"

