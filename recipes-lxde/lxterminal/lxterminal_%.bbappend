FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0002-man-Makefile.am-don-t-error-out-on-missing-man-depen.patch \
"
