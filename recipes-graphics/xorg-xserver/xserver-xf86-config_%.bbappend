FILESEXTRAPATHS_prepend := "${THISDIR}/xserver-xf86-config:"

SRC_URI += " \
    file://display_7in.patch \
"
